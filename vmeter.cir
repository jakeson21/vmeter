* EESchema Netlist Version 1.1 (Spice format) creation date: 6/7/2014 5:08:00 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
U2  N-000054 GND N-000049 /-5V ? ? +5V ICL7660CBAZ
U1  ? ? N-000048 N-000047 ? N-000046 N-000045 +5V N-000020 N-000019 N-000017 N-000016 N-000014 N-000013 N-000021 /D2 /C2 /B2 /A2 /F2 /E2 N-000009 N-000007 N-000006 N-000010 N-000004 N-000008 GND N-000005 N-000001 N-000043 /G2 ? /-5V N-000051 N-000050 N-000057 GND N-000044 N-000040 N-000059 N-000056 N-000040 N-000052 ICL7107CM44Z
R1  N-000046 N-000045 100k
C1  N-000047 N-000045 100pF
C2  N-000056 N-000059 100nF
C4  N-000058 N-000057 470nF
C3  N-000058 N-000051 220nF
R2  N-000050 N-000058 47k
J2  /V+meas GND MEAS
R3  N-000044 /V+meas 100k
C5  GND N-000044 10nF
RV1  N-000040 N-000052 N-000053 10K
R4  N-000053 +5V 15K
CP6  N-000054 N-000049 10uF
J3  GND +5V PWR_IN
J4  /-5V GND +5V HEADER_3
J5  N-000040 TP3
J6  N-000052 TP2
J1  N-000048 TP1
J7  N-000045 TP5
J8  N-000051 TP4
R5  GND N-000030 220
DS1  ? ? /CA ? ? N-000010 N-000009 /CA N-000043 N-000030 N-000007 N-000001 /CA N-000006 N-000005 N-000004 N-000004 /CA ? N-000008 LED_DUAL7SEG_ACDA04
DS2  /E2 /D2 /CA /C2 ? N-000021 N-000020 /CA N-000019 ? N-000017 N-000016 /CA N-000014 N-000013 /B2 /A2 /CA /F2 /G2 LED_DUAL7SEG_ACDA04
D1  N-000041 /CA 1N4148
D2  +5V N-000041 1N4148
CP7  /-5V GND 10uF
R6  GND N-000044 10k

.end
